# Keil uVision project RTOS_Hello.uvprojx, settings and files
target RTOS_Hello (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RTOS_Hello
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_LL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\Drivers\Components\OnChip\Inc;..\Drivers\Components\OnBoard\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c queue.c list.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: main.c stm32l4xx_it.c
  group Drivers/STM32L4xx_LL_Driver
    ../Drivers/STM32L4xx_LL_Driver/Src/: stm32l4xx_ll_exti.c stm32l4xx_ll_utils.c stm32l4xx_ll_pwr.c stm32l4xx_ll_gpio.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c
  group Drivers/STM32L4xx_OnChip_Driver
    ../Drivers/Components/OnChip/Src/: QSPI.c
software components: CMSIS:CORE 4.1.0
